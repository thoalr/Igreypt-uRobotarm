# Keil uVision project ProjectRobotarm.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectRobotarm
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\ProjectRobotarm.sct
  group Source Group 1
    ./: main.c stdf.c robotf.c robot_io.c other_io.c stdf.h robot_io.h
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX5 5.1.0, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.1
